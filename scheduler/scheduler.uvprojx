# Keil uVision project scheduler.uvprojx, settings and files
target STM32F207VGTx (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F207VGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: scheduler
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group kernel
    ./: kernel.c kernel.s kernel.h
  group user
    ./: main.c
software components: CMSIS:CORE 5.0.0, Device:Startup 2.1.1
